File: piano_layout/daisy_seed.kicad_sch (KiCad schematic)
At the start: 1 part

Commit message: updated readme
Other:
- title: (none) -> Daisy Seed Pinout
- moved on the sheet: A1
